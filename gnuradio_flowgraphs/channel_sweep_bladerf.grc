options:
  parameters:
    author: DoA Thesis Project
    category: '[AoA Estimation]'
    comment: |-
      WiFi channel sweep DoA estimation for BladeRF 2.0 MIMO
      Select WiFi channel 1-14 to retune in real-time
      Based on Wachowiak & Kryszkiewicz (2022)
    description: Direction of Arrival estimation with WiFi channel selection
    generate_options: qt_gui
    id: channel_sweep_bladerf
    output_language: python
    title: BladeRF AoA Channel Sweep
  states: {}

blocks:
- name: antenna_spacing
  id: variable
  parameters:
    comment: d/lambda = 0.0612 / (3e8/center_freq), varies per channel
    value: 0.0612 / (3e8 / center_freq)
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Computed from wifi_channel. Ch14 has 12 MHz gap.
    value: (2412e6 + (wifi_channel - 1) * 5e6) if wifi_channel <= 13 else 2484e6
  states: {}
- name: phase_cal_deg
  id: variable_qtgui_range
  parameters:
    comment: Enter calibration coefficient from phase_calibration flowgraph
    gui_hint: 0,1,1,1
    label: Phase Cal (deg)
    start: '-180'
    step: '0.1'
    stop: '180'
    value: '0'
  states: {}
- name: phase_cal_rad
  id: variable
  parameters:
    value: phase_cal_deg * 3.14159265359 / 180.0
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: 1 MSPS — USB 2.0 limited on Zynq
    value: 1e6
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    comment: 'Samples per MUSIC snapshot (per paper: 1024)'
    value: '1024'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: TX tone offset frequency
    value: 50e3
  states: {}
- name: wifi_channel
  id: variable_qtgui_chooser
  parameters:
    comment: WiFi 2.4 GHz channel selector
    gui_hint: 0,0,1,1
    label: WiFi Channel
    label0: Ch 1 (2412 MHz)
    label1: Ch 2 (2417 MHz)
    label2: Ch 3 (2422 MHz)
    label3: Ch 4 (2427 MHz)
    label4: Ch 5 (2432 MHz)
    labels: '["Ch 6 (2437)", "Ch 7 (2442)", "Ch 8 (2447)", "Ch 9 (2452)", "Ch 10 (2457)", "Ch 11 (2462)", "Ch 12 (2467)", "Ch 13 (2472)", "Ch 14 (2484)"]'
    num_opts: '5'
    option0: '1'
    option1: '2'
    option2: '3'
    option3: '4'
    option4: '5'
    options: '[6, 7, 8, 9, 10, 11, 12, 13, 14]'
    type: int
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: Calibration phase in radians
    const: phase_cal_rad
    type: float
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    comment: Compute covariance matrix for MUSIC
    num_inputs: '2'
    overlap_size: '0'
    snapshot_size: snapshot_size
  states: {}
- name: aoa_music_lin_array_0
  id: aoa_music_lin_array
  parameters:
    comment: MUSIC pseudo-spectrum for visualization
    norm_spacing: antenna_spacing
    num_inputs: '2'
    num_targets: '1'
    pspectrum_len: '1024'
  states: {}
- name: aoa_root_music_linear_array_0
  id: aoa_root_music_linear_array
  parameters:
    comment: |-
      Root-MUSIC DoA estimator
      2 elements, 1 source
      d/lambda varies with channel
    norm_spacing: antenna_spacing
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: aoa_shift_phase_0
  id: aoa_shift_phase_multiple_hier
  parameters:
    comment: Apply phase calibration coefficient to CH1
    num_signals: '1'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Filter CH0
    decim: '1'
    gain: '1'
    high_cutoff_freq: tone_freq + 10e3
    low_cutoff_freq: tone_freq - 10e3
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    comment: Filter CH1
    decim: '1'
    gain: '1'
    high_cutoff_freq: tone_freq + 10e3
    low_cutoff_freq: tone_freq - 10e3
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    comment: Spectrum — see interference per channel
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 6,0,2,2
    label1: CH0
    label2: CH1
    name: '"Spectrum"'
    nconnections: '2'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-80'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    color1: ("blue", "red")
    comment: ESTIMATED ANGLE OF ARRIVAL
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,2
    label1: AoA
    max: '180'
    min: '0'
    name: '"Angle of Arrival (deg)"'
    type: float
    unit1: deg
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: AoA estimate over time
    grid: 'True'
    gui_hint: 3,0,2,2
    label1: AoA
    name: '"AoA Time Series"'
    size: '5000'
    srate: sample_rate/snapshot_size
    type: float
    update_time: '0.1'
    ylabel: Angle (deg)
    ymax: '180'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    comment: MUSIC spatial spectrum
    grid: 'True'
    gui_hint: 5,0,1,2
    label1: MUSIC Spectrum
    name: '"MUSIC Pseudo-Spectrum"'
    update_time: '0.2'
    vlen: '1024'
    x_axis_label: '"Angle (deg)"'
    x_start: '0'
    x_step: 180.0/1024
    x_units: '"deg"'
    y_axis_label: '"Power (dB)"'
    y_units: '"dB"'
    ymax: '0'
    ymin: '-60'
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_source_safe
  parameters:
    agc0: 'False'
    agc1: 'False'
    amp_gain0: '0'
    ant0: RX
    ant1: RX
    balance0: '0'
    balance1: '0'
    bw0: '0'
    bw1: '0'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: '0'
    clock_source: ''
    comment: BladeRF 2.0 MIMO — retunes when WiFi channel changes
    correction0: '0'
    correction1: '0'
    dc_offset0: '0'
    dc_offset1: '0'
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev: driver=bladerf
    dev_args: ''
    devname: bladerf
    gain_mode0: Overall
    gain_mode1: Overall
    ifgr_gain: '59'
    lna_gain0: '10'
    lna_gain1: '10'
    mix_gain0: '10'
    nchan: '2'
    nco_freq0: '0'
    nco_freq1: '0'
    overall_gain0: rx_gain
    overall_gain1: rx_gain
    pga_gain0: '24'
    pga_gain1: '24'
    rf_gain0: '18'
    rfgr_gain: '9'
    rxvga1_gain: '5'
    rxvga2_gain: '0'
    samp_rate: sample_rate
    sdrplay_agc_setpoint: '-30'
    sdrplay_biastee: 'False'
    sdrplay_dabnotch: 'False'
    sdrplay_if_mode: Zero-IF
    sdrplay_rfnotch: 'False'
    settings0: ''
    settings1: ''
    stream_args: ''
    tia_gain0: '0'
    tia_gain1: '0'
    tune_args0: ''
    tune_args1: ''
    tuner_gain0: '10'
    type: fc32
    vga_gain0: '10'
  states: {}

connections:
- [analog_const_source_x_0, '0', aoa_shift_phase_0, '1']
- [aoa_autocorrelate_0, '0', aoa_music_lin_array_0, '0']
- [aoa_autocorrelate_0, '0', aoa_root_music_linear_array_0, '0']
- [aoa_music_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_number_sink_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_time_sink_x_0, '0']
- [aoa_shift_phase_0, '0', aoa_autocorrelate_0, '1']
- [band_pass_filter_0, '0', aoa_autocorrelate_0, '0']
- [band_pass_filter_1, '0', aoa_shift_phase_0, '0']
- [soapy_bladerf_source_0, '0', band_pass_filter_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_bladerf_source_0, '1', band_pass_filter_1, '0']
- [soapy_bladerf_source_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
