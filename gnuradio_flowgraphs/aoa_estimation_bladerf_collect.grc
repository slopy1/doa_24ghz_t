options:
  parameters:
    author: DoA Thesis Project
    category: '[AoA Estimation]'
    comment: AoA estimation flowgraph for BladeRF 2.0 MIMO\nBased on Wachowiak & Kryszkiewicz (2022)\nUses Root-MUSIC algorithm
    description: Real-time Direction of Arrival estimation using Root-MUSIC
    generate_options: qt_gui
    id: aoa_estimation_bladerf_collect
    output_language: python
    title: BladeRF AoA Estimation (Root-MUSIC) [COLLECT]
  states: {}

blocks:
- name: antenna_spacing
  id: variable
  parameters:
    comment: Normalized spacing d/lambda = 0.5 for lambda/2
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: nRF53 Channel 24 = 2450 MHz
    value: 2.42e9
  states: {}
- name: phase_cal_deg
  id: variable_qtgui_range
  parameters:
    comment: Enter the calibration coefficient from phase_calibration flowgraph
    gui_hint: 0,1,1,1
    label: Phase Cal (deg)
    start: '-180'
    step: '0.1'
    stop: '180'
    value: '0'
  states: {}
- name: phase_cal_rad
  id: variable
  parameters:
    value: phase_cal_deg * 3.14159265359 / 180.0
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: snapshot_size
  id: variable
  parameters:
    comment: 'Samples per MUSIC snapshot (per paper: 1024)'
    value: '1024'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: nRF53 transmits at center freq (no offset)
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: Calibration phase in radians
    const: phase_cal_rad
    type: float
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    comment: Compute covariance matrix for MUSIC
    num_inputs: '2'
    overlap_size: '0'
    snapshot_size: snapshot_size
  states: {}
- name: aoa_music_lin_array_0
  id: aoa_music_lin_array
  parameters:
    comment: MUSIC pseudo-spectrum for visualization
    norm_spacing: antenna_spacing
    num_inputs: '2'
    num_targets: '1'
    pspectrum_len: '1024'
  states: {}
- name: aoa_root_music_linear_array_0
  id: aoa_root_music_linear_array
  parameters:
    comment: Root-MUSIC DoA estimator\n2 elements, 1 source, lambda/2 spacing
    norm_spacing: antenna_spacing
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: aoa_shift_phase_multiple_hier_0
  id: aoa_shift_phase_multiple_hier
  parameters:
    num_signals: '1'
  states: {}
- name: file_sink_ch0
  id: blocks_file_sink
  parameters:
    comment: Raw IQ CH0
    file: /home/mau/doa_24ghz_thesis/data/aoa_ch0.32fc
    type: complex
  states: {}
- name: file_sink_ch1
  id: blocks_file_sink
  parameters:
    comment: Raw IQ CH1
    file: /home/mau/doa_24ghz_thesis/data/aoa_ch1.32fc
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Filter CH0 - lowpass for nRF53 at center freq
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Filter CH1 - lowpass for nRF53 at center freq
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    comment: Verify signal presence
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 6,0,2,2
    label1: CH0
    label2: CH1
    name: '"Spectrum"'
    nconnections: '2'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-80'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    color1: ("blue", "red")
    comment: ESTIMATED ANGLE OF ARRIVAL
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,2
    label1: AoA
    max: '180'
    min: '0'
    name: '"Angle of Arrival (deg)"'
    type: float
    unit1: deg
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: AoA estimate over time
    grid: 'True'
    gui_hint: 2,0,2,2
    label1: AoA
    name: '"AoA Time Series"'
    size: '5000'
    srate: sample_rate/snapshot_size
    type: float
    update_time: '0.1'
    ylabel: Angle (deg)
    ymax: '180'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    comment: MUSIC spatial spectrum
    grid: 'True'
    gui_hint: 4,0,2,2
    label1: MUSIC Spectrum
    name: '"MUSIC Pseudo-Spectrum"'
    update_time: '0.2'
    vlen: '1024'
    x_axis_label: '"Angle (deg)"'
    x_start: '0'
    x_step: 180.0/1024
    x_units: '"deg"'
    y_axis_label: '"Power (dB)"'
    y_units: '"dB"'
    ymax: '0'
    ymin: '-60'
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_source_safe
  parameters:
    agc0: 'False'
    agc1: 'False'
    amp_gain0: '0'
    ant0: RX
    ant1: RX
    balance0: '0'
    balance1: '0'
    bw0: '0'
    bw1: '0'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: '0'
    clock_source: ''
    comment: BladeRF 2.0 MIMO Source
    correction0: '0'
    correction1: '0'
    dc_offset0: '0'
    dc_offset1: '0'
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev: driver=bladerf
    dev_args: ''
    devname: bladerf
    gain_mode0: Overall
    gain_mode1: Overall
    ifgr_gain: '59'
    lna_gain0: '10'
    lna_gain1: '10'
    mix_gain0: '10'
    nchan: '2'
    nco_freq0: '0'
    nco_freq1: '0'
    overall_gain0: '10'
    overall_gain1: '10'
    pga_gain0: '24'
    pga_gain1: '24'
    rf_gain0: '18'
    rfgr_gain: '9'
    rxvga1_gain: '5'
    rxvga2_gain: '0'
    samp_rate: sample_rate
    sdrplay_agc_setpoint: '-30'
    sdrplay_biastee: 'False'
    sdrplay_dabnotch: 'False'
    sdrplay_if_mode: Zero-IF
    sdrplay_rfnotch: 'False'
    settings0: ''
    settings1: ''
    stream_args: ''
    tia_gain0: '0'
    tia_gain1: '0'
    tune_args0: ''
    tune_args1: ''
    tuner_gain0: '10'
    type: fc32
    vga_gain0: '10'
  states: {}

connections:
- [analog_const_source_x_0, '0', aoa_shift_phase_multiple_hier_0, '1']
- [aoa_autocorrelate_0, '0', aoa_music_lin_array_0, '0']
- [aoa_autocorrelate_0, '0', aoa_root_music_linear_array_0, '0']
- [aoa_music_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_number_sink_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_time_sink_x_0, '0']
- [aoa_shift_phase_multiple_hier_0, '0', aoa_autocorrelate_0, '1']
- [low_pass_filter_0, '0', aoa_autocorrelate_0, '0']
- [low_pass_filter_1, '0', aoa_shift_phase_multiple_hier_0, '0']
- [soapy_bladerf_source_0, '0', file_sink_ch0, '0']
- [soapy_bladerf_source_0, '0', low_pass_filter_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_bladerf_source_0, '1', file_sink_ch1, '0']
- [soapy_bladerf_source_0, '1', low_pass_filter_1, '0']
- [soapy_bladerf_source_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
