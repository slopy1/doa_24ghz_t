options:
  parameters:
    author: DoA Thesis Project
    category: '[AoA Calibration]'
    comment: Phase calibration flowgraph for BladeRF 2.0 MIMO\nBased on Wachowiak & Kryszkiewicz (2022)
    description: Measures phase offset between RX channels using wired calibration
    generate_options: qt_gui
    id: phase_calibration_bladerf_collect
    output_language: python
    title: BladeRF Phase Calibration [COLLECT]
  states: {}

blocks:
- name: avg_length
  id: variable
  parameters:
    comment: Moving average length for phase stability
    value: '100000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: nRF53 Channel 24 = 2450 MHz
    value: 2.42e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: nRF53 transmits at center freq (no offset)
    value: '0'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    comment: Extract phase in radians
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mau/doa_24ghz_thesis/data/data.txt
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: Average 100k samples for stable phase
    length: avg_length
    max_iter: '4000'
    scale: 1.0/avg_length
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Compute CH0 * conj(CH1)\nPhase = angle of this product
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert radians to degrees
    const: 180.0/3.14159265359
    type: float
  states: {}
- name: file_sink_raw_ch0
  id: blocks_file_sink
  parameters:
    comment: Raw IQ CH0
    file: /home/mau/doa_24ghz_thesis/data/cal_ch0.32fc
    type: complex
  states: {}
- name: file_sink_raw_ch1
  id: blocks_file_sink
  parameters:
    comment: Raw IQ CH1
    file: /home/mau/doa_24ghz_thesis/data/cal_ch1.32fc
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Filter CH0 - lowpass for nRF53 at center freq
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Filter CH1 - lowpass for nRF53 at center freq
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    comment: Verify calibration tone at 50kHz offset
    fc: 2.425e9
    fftsize: '4096'
    grid: 'True'
    gui_hint: 4,0,2,2
    label1: CH0
    label2: CH1
    name: '"Spectrum (verify tone)"'
    nconnections: '2'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-80'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.2'
    color1: ("blue", "red")
    comment: CALIBRATION COEFFICIENT\nRecord this value when stable
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,2
    label1: Phase Offset (deg)
    max: '180'
    min: '-180'
    name: '"Phase Calibration Coefficient"'
    type: float
    unit1: deg
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Monitor phase stability over time
    grid: 'True'
    gui_hint: 2,0,2,2
    label1: Phase Offset
    name: '"Phase Stability"'
    size: '10000'
    srate: sample_rate/avg_length
    type: float
    update_time: '0.1'
    ylabel: Phase (deg)
    ymax: '45'
    ymin: '-45'
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_source_safe
  parameters:
    agc0: 'False'
    agc1: 'False'
    amp_gain0: '0'
    ant0: RX
    ant1: RX
    balance0: '0'
    balance1: '0'
    bw0: '40_000_000'
    bw1: '40_000_000'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: '0'
    clock_source: ''
    comment: BladeRF 2.0 MIMO Source\nBoth channels must have identical settings
    correction0: '0'
    correction1: '0'
    dc_offset0: '0'
    dc_offset1: '0'
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev: driver=bladerf
    dev_args: ''
    devname: bladerf
    gain_mode0: Overall
    gain_mode1: Overall
    ifgr_gain: '59'
    lna_gain0: '10'
    lna_gain1: '10'
    mix_gain0: '10'
    nchan: '2'
    nco_freq0: '0'
    nco_freq1: '0'
    overall_gain0: rx_gain
    overall_gain1: rx_gain
    pga_gain0: '24'
    pga_gain1: '24'
    rf_gain0: '18'
    rfgr_gain: '9'
    rxvga1_gain: '5'
    rxvga2_gain: '0'
    samp_rate: sample_rate
    sdrplay_agc_setpoint: '-30'
    sdrplay_biastee: 'False'
    sdrplay_dabnotch: 'False'
    sdrplay_if_mode: Zero-IF
    sdrplay_rfnotch: 'False'
    settings0: ''
    settings1: ''
    stream_args: ''
    tia_gain0: '0'
    tia_gain1: '0'
    tune_args0: ''
    tune_args1: ''
    tuner_gain0: '10'
    type: fc32
    vga_gain0: '10'
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [soapy_bladerf_source_0, '0', file_sink_raw_ch0, '0']
- [soapy_bladerf_source_0, '0', low_pass_filter_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_bladerf_source_0, '1', file_sink_raw_ch1, '0']
- [soapy_bladerf_source_0, '1', low_pass_filter_1, '0']
- [soapy_bladerf_source_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
